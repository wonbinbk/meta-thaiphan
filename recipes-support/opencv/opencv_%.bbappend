PACKAGECONFIG:remove = " gstreamer"
PACKAGECONFIG:append = " libav"
DEPENDS:append = " libav"
